# Keil uVision project FUSIONSDK.uvproj, settings and files
target FUSIONSDK (ARM-ADS)
  device: NUC123SD4AN0 Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x10FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: FUSIONSDK
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1
  c include: .\;..\..\..\..\HW;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;..\..\..\Include;..\..\..\Include\Driver;..\..\..\Include\USB;..\..\..\..\CMSIS\CM0\CoreSupport;..\AHRSLib\include
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/startup/arm/: startup_NUC1xx.s
  group Source files
    ./: FUSIONSDK.c MPU6050.c MPU6050.h I2Cdev.c NVT_I2C.c NVT_I2C.h Timer_Ctrl.c Timer_Ctrl.h hmc5883l.c hmc5883l.h Def.h Config.h Sensors.c Sensors.h FlashCtrl.c FlashCtrl.h I2Cdev.h Report.c Report.h Calibrate.c Calibrate.h ak8975.c ak8975.h Adafruit_BMP085.c Adafruit_BMP085.h RC.c RC.h controller.c controller.h param.h pid.c pid.h stabilizer.c stabilizer.h motors.c motors.h AltHold.c AltHold.h ms5611.c ms5611.h
  group Library files
    ../../../Src/Driver/: DrvSYS.c DrvUART.c DrvSPI.c DrvTIMER.c DrvFMC.c
    ./: retarget.c retarget.h
    ../AHRSLib/include/: AHRSLib.h
    ../AHRSLib/obj/: AHRSLib.lib
    ./Driver/: DrvGPIO.c DrvI2C.c DrvPWM.c
