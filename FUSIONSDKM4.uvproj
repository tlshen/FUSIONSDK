# Keil uVision project FUSIONSDKM4.uvproj, settings and files
target FUSIONSDKM4 (ARM-ADS)
  device: M453VG6AE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: FUSIONSDKM4
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 wLevel=2
  c define: M451
  c include: ..\..\..\Library\Device\Nuvoton\M451Series\Include;..\..\..\Library\StdDriver\inc;.\include;..\AHRSLib\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M451series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
    ../../../Library/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
  group User
    ./: Adafruit_BMP085.c ak8975.c AltHold.c Calibrate.c controller.c FlashCtrl.c FUSIONSDK.c hmc5883l.c I2Cdev.c motors.c MPU6050.c NVT_I2C.c pid.c RC.c Report.c Sensors.c stabilizer.c Timer_Ctrl.c ms5611.c RC_pwm.c LED.c ssv7241.c RC_ssv.c battery.c BMP280.c gps.c ist8310_driver.c
  group Library
    ../../../Library/StdDriver/src/: gpio.c i2c.c pwm.c timer.c sys.c uart.c clk.c fmc.c spi.c eadc.c
    ./: retarget.c
    ../AHRSLib/obj/: AHRSLibM4.lib
  group Include
    ./: Adafruit_BMP085.h ak8975.h AltHold.h Calibrate.h Config.h controller.h Def.h FlashCtrl.h hmc5883l.h I2CDev.h motors.h MPU6050.h NVT_I2C.h param.h pid.h RC.h Report.h retarget.h Sensors.h stabilizer.h Timer_Ctrl.h ms5611.h LED.h ssv7241.h RC_ssv.h RC_pwm.h battery.h BMP280.h gps.h IST8310_driver.h
    ../AHRSLib/include/: AHRSLib.h
